# Keil uVision project SV300_app.uvproj, settings and files
target SV300_app (ARM-ADS)
  device: LPC4357:Cortex-M4 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: SV300_app
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File "$P..\tools\gen_web_gz.ps1"
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 wLevel=1
  c define: LPC4330 USE_LPCXPRESSO_4337 CMSIS_BITPOSITIONS GPL_LICENSE_TERMS_ACCEPTED CORE_M4 USE_KSZ8863 GEMS9000 EXT_RTC _FTP_SERVER VFRMS METER_TEST_DATA _WDT_EN
  c include: ..\src;..\third_party\cmsis\include;..\third_party\nxp\devices\lpc43xx;..\third_party\nxp\boards\lpcxpresso_4337;..\third_party\freertos\include;..\third_party\freertos\portable\rvds\arm_cm4f;..\common;..\cyclone_driver\cyclone_stp;..\cyclone_driver\cyclone_tcp;..\cyclone_driver\cyclone_crypto;..\lpc_chip\chip_18xx_43xx\config_43xx;..\lpc_chip\chip_18xx_43xx;..\lpc_chip\chip_common;..\lpc_board\boards_43xx\ea_oem_4357;..\lpc_board\board_common;..\wiznet
  memory RVCT4: ROM 0x1a020000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT7: RAM 0x28400000 size 0xc00000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\SV300_app.sct
  group Demo Sources
    ./: startup_lpc43xx.s retarget.c
    ../src/: main.c debug.c smi_driver.c FS.c sysinit.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h stp_config.h net_config_ftp_client_demo.h net_config_rstp.h ade9000.h fft.h FS.h meter.h os.h Terminal.h fs_port_config.h
  group Common Sources
    ../common/: cpu_endian.c date_time.c str.c os_port_rtx.c fs_port_rtx.c path.c
  group Common Headers
    ../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h fs_port.h fs_port_rtx.h
  group CycloneTCP Sources
    ../cyclone_driver/cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../cyclone_driver/cyclone_tcp/drivers/mac/: lpc43xx_eth_driver.c
    ../cyclone_driver/cyclone_tcp/drivers/phy/: lan8720_driver.c dm8603_driver.c
    ../cyclone_driver/cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c auto_ip.c auto_ip_misc.c
    ../cyclone_driver/cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../cyclone_driver/cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../cyclone_driver/cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../cyclone_driver/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../cyclone_driver/cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../cyclone_driver/cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../cyclone_driver/cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../cyclone_driver/cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../cyclone_driver/cyclone_tcp/ftp/: ftp_client.c ftp_client_transport.c ftp_client_misc.c ftp_server.c ftp_server_commands.c ftp_server_control.c ftp_server_data.c ftp_server_transport.c ftp_server_misc.c
    ../cyclone_driver/cyclone_tcp/drivers/switch/: ksz8863_driver.c
    ../cyclone_driver/cyclone_tcp/modbus/: modbus_debug.c modbus_server.c modbus_server_misc.c modbus_server_pdu.c modbus_server_security.c modbus_server_transport.c
    ../cyclone_driver/cyclone_tcp/sntp/: sntp_client.c sntp_client_misc.c
    ../cyclone_driver/cyclone_tcp/http/: http_server.c http_server_misc.c http_server_auth.c http_common.c mime.c
  group CycloneTCP Headers
    ../cyclone_driver/cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../cyclone_driver/cyclone_tcp/drivers/mac/: lpc43xx_eth_driver.h
    ../cyclone_driver/cyclone_tcp/drivers/phy/: lan8720_driver.h
    ../cyclone_driver/cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../cyclone_driver/cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../cyclone_driver/cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../cyclone_driver/cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../cyclone_driver/cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../cyclone_driver/cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../cyclone_driver/cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../cyclone_driver/cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../cyclone_driver/cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../cyclone_driver/cyclone_tcp/ftp/: ftp_client.h ftp_client_transport.h ftp_client_misc.h
    ../cyclone_driver/cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_inform.c snmp_agent_message.c snmp_agent_misc.c snmp_agent_object.c snmp_agent_pdu.c snmp_agent_trap.c snmp_agent_usm.c snmp_agent_vacm.c
    ../cyclone_driver/cyclone_tcp/mqtt/: mqtt_client.c mqtt_client_misc.c mqtt_client_packet.c mqtt_client_transport.c
    ../cyclone_driver/cyclone_tcp/mibs/: snmp_mib_impl.c snmp_mib_module.c mib_common.c
    ../cyclone_driver/cyclone_tcp/modbus/: modbus_debug.h modbus_server.h modbus_server_misc.h modbus_server_pdu.h modbus_server_security.h modbus_server_transport.h
  group LPCXpresso4337 Headers
    ../third_party/nxp/boards/lpcxpresso_4337/: lpcxpresso_4337.h
  group lpc_chip
    ../lpc_chip/chip_18xx_43xx/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c chip_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c gpiogroup_18xx_43xx.c hsadc_18xx_43xx.c i2c_18xx_43xx.c i2cm_18xx_43xx.c i2s_18xx_43xx.c iap_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pinint_18xx_43xx.c pmc_18xx_43xx.c rgu_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c sct_pwm_18xx_43xx.c scu_18xx_43xx.c sdif_18xx_43xx.c sdmmc_18xx_43xx.c spi_18xx_43xx.c ssp_18xx_43xx.c stopwatch_18xx_43xx.c sysinit_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c
    ../lpc_chip/chip_common/: eeprom.c fpu_init.c ring_buffer.c
  group lpc_board
    ../lpc_board/boards_43xx/: board.c board_sysinit.c
  group STP
    ../cyclone_driver/cyclone_stp/rstp/: rstp.c rstp_bdm.c rstp_bpdu.c rstp_conditions.c rstp_fsm.c rstp_mgmt.c rstp_misc.c rstp_pim.c rstp_ppm.c rstp_procedures.c rstp_prs.c rstp_prt.c rstp_prx.c rstp_pst.c rstp_pti.c rstp_ptx.c rstp_tcm.c
    ../cyclone_driver/cyclone_stp/mibs/: bridge_mib_impl.c bridge_mib_impl_base.c bridge_mib_impl_static.c bridge_mib_impl_stp.c bridge_mib_impl_tp.c bridge_mib_module.c rstp_mib_impl.c rstp_mib_module.c
  group CRYPTO
    ../cyclone_driver/cyclone_crypto/hash/: md5.c sha1.c sha512.c
    ../cyclone_driver/cyclone_crypto/mac/: hmac.c
    ../cyclone_driver/cyclone_crypto/cipher/: des.c aes.c
    ../cyclone_driver/cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../cyclone_driver/cyclone_crypto/ecc/: curve25519.c ed25519.c
    ../cyclone_driver/cyclone_crypto/encoding/: asn1.c oid.c
  group MDK
    ../src/: File_Config.c SDIO_LPC43xx.c FS_CM3.lib RTX_CM4.lib RTX_Conf_CM.c
  group Application
    ../src/: ade9000.c meter.c web.c snmp_trap.c mqtt_app.c snmp_cfg.c ssplib.c app_main.c fft_radix2_czt.c alarm.c smb_tcp.c smb_rtu.c modbus.c Quality.c crc.c gateway.c ETC.c iom.c temp_sensor.c FS_SPIFI_FlashPrg.c Getline.c proxy.c
target SV300_3CH_app (ARM-ADS)
  device: LPC4357:Cortex-M4 NXP (founded by Philips)
  cpu: as above
  output: SV300_3CH_app
  BeforeMake: as above
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 wLevel=1
  c define: LPC4330 USE_LPCXPRESSO_4337 CMSIS_BITPOSITIONS GPL_LICENSE_TERMS_ACCEPTED CORE_M4 USE_KSZ8863 GEMS9000 EXT_RTC _FTP_SERVER VFRMS NOSDMEM HWV1 CH3
  c include: as above
  memory RVCT4: ROM 0x1a020000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT7: RAM 0x28400000 size 0xc00000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\SV300_app.sct
target SV300_3CH_app_16M (ARM-ADS)
  device: LPC4357:Cortex-M4 NXP (founded by Philips)
  cpu: as above
  output: SV300_3CH_app_16M
  BeforeMake: as above
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 wLevel=1
  c define: LPC4330 USE_LPCXPRESSO_4337 CMSIS_BITPOSITIONS GPL_LICENSE_TERMS_ACCEPTED CORE_M4 USE_KSZ8863 GEMS9000 EXT_RTC _FTP_SERVER VFRMS NOSDMEM HWV1 CH3 _WDT_EN HWV2
  c include: as above
  memory RVCT4: ROM 0x1a020000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT7: RAM 0x28400000 size 0xc00000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\SV300_app.sct
