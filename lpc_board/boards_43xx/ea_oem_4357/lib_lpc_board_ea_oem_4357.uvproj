# Keil uVision project lib_lpc_board_ea_oem_4357.uvproj, settings and files
target ea_oem_4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lib_lpc_board_ea_oem_4357 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\board_common;..\..\..\lpc_chip\chip_18xx_43xx;..\..\..\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\lpc_chip\chip_common;.\
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\keil_output\core_m4\lib_lpc_board_ea_oem_4357.sct
  group src
    ./: board.c board_sysinit.c
    ../../board_common/: calibrate.c ea_lcd_board.c lcdb_eeprom.c lpc_phy_smsc87x0.c mem_tests.c nand.c norflash.c pca9532.c tda19988.c tfp410.c tsc2046_touch.c uda1380.c
